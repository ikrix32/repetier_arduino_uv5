# Keil uVision project repetier_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_NRF6310 ARDUINO __SAM3X8E__
  c misc: --cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../repetier/: Commands.cpp Commands.h Communication.cpp Communication.h Configuration.h Eeprom.cpp Eeprom.h Extruder.cpp Extruder.h fastio.h FatStructs.h gcode.cpp gcode.h HAL.cpp HAL.h messages.cpp messages.h motion.cpp motion.h pins.h Printer.cpp Printer.h Repetier.h Repetier.ino.cpp SDCard.cpp SdFat.cpp SdFat.h TODO.h u8glib_ex.h ui.cpp ui.h uiconfig.h uilang.h uimenu.h
  group Arduino
    ../../../arduino/: Arduino.h binary.h HardwareSerial.h hooks.c itoa.c itoa.h main.cpp new.cpp Print.cpp Print.h Printable.h RingBuffer.cpp RingBuffer.h Stream.cpp Stream.h Tone.cpp Tone.h UARTClass.cpp UARTClass.h WCharacter.h WInterrupts.c WInterrupts.h wiring.c wiring.h wiring_analog.c wiring_analog.h wiring_constants.h wiring_digital.c wiring_digital.h wiring_pulse.cpp wiring_pulse.h wiring_shift.c wiring_shift.h WMath.cpp WMath.h WString.cpp WString.h wuart.cpp wuart.h dtoa.c dtoa.h
  group Arduino_nrf51822
    ../../../arduino_nrf51822/: app_error_check.c app_error_check.h pin_transform.c pin_transform.h pins_arduino.h variant.cpp variant.h
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_error.c app_error.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h app_util_platform.c nrf_assert.c nrf_assert.h
software components: CMSIS:CORE , Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:nrf_assert 1.1.0
